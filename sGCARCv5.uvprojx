# Keil uVision project sGCARCv5.uvprojx, settings and files
target sGCARCv5 (6190000::V6.19::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sGCARCv5
  c flags: Optim=4 oTime=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=6 v6Lto=1 wLevel=3
  c define: STM32F405xx,USE_HAL_DRIVER,ARM_MATH_CM4
  c include: .;sAPP;sBSP;sDBG;sDRV;sMID;sUSER;sLIB\STM32F4xx_HAL_Driver\Inc;sLIB\CMSIS\Include;sLIB\CMSIS\Device\ST\STM32F4xx\Include;sLIB\CMSIS\Core\Include;sLIB\CMSIS\DSP\Include;sMID\sGenBtnDrv2;sMID\sLib;sMID\sGraphic2D;sMID\FreeRTOS\include;sMID\FreeRTOS\portable\GCC;sMID\FreeRTOS;sMID\cm_backtrace;sMID\sBinOutDrv;sMID\sLittleMenu;sMID\sDWTLib;sMID\ArduinoFramework
  asm define: STM32F405xx,USE_HAL_DRIVER,ARM_MATH_CM4
  memory RVCT1: ROM 0x8000000 size 0x10000
  memory RVCT6: RAM 0x20000000 size 0x5000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: build/sGCARCv5.sct
  group SAPP
    sAPP/: sAPP_AHRS.cpp sAPP_BinOutDev.cpp sAPP_BlcCtrl.cpp sAPP_Btns.cpp sAPP_Car.cpp sAPP_FileSys.cpp sAPP_GUI.cpp sAPP_Init.c sAPP_Motor.cpp sAPP_ParamSave.cpp sAPP_RC.cpp sAPP_Tasks.cpp
  group SBSP
    sBSP/: sBSP_ADC.c sBSP_DMA.c sBSP_DWT.c sBSP_GPIO.c sBSP_I2C.c sBSP_IWDG.c sBSP_RCC.c sBSP_RNG.c sBSP_SPI.c sBSP_SYS.c sBSP_TIM.c sBSP_UART.c
  group SDBG
    sDBG/: sDBG_Debug.c
  group SDRV
    sDRV/: sDRV_DRV8870.c sDRV_Flash.c sDRV_GMR.c sDRV_ICM42688.c sDRV_ICM45686.c sDRV_INA219.c sDRV_JY901S.c sDRV_LED.cpp sDRV_LIS3MDLTR.c sDRV_MB85RCxx.c sDRV_GrayScale.c sDRV_NTC.c sDRV_PS2.c sDRV_PwrLight.c sDRV_TrackTube8.c sDRV_UART6_HostComm.cpp
  group SMID/SLITTLEMENU
    sMID/sLittleMenu/: sLittleMenu.cpp sLM_OLED128X64.cpp
  group SMID/SLIB
    sMID/sLib/: sLib.c sLib_Ctrler.c sLib_Filter.c sLib_Reg.c
  group SMID/SGRAPHIC2D
    sMID/sGraphic2D/: sDRV_GenOLED.c sG2D.cpp
  group SMID/SGENBTNDRV2
    sMID/sGenBtnDrv2/: sGenBtnDrv2.c
  group SMID/SDWTLIB
    sMID/sDWTLib/: sDWTLib.cpp
  group SMID/SBINOUTDRV
    sMID/sBinOutDrv/: sBinOutDev.cpp
  group SMID/FREERTOS/SRC
    sMID/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group SMID/FREERTOS/PORTABLE/MEMMANG
    sMID/FreeRTOS/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4 - 副本.c heap_4.c heap_5.c
  group SMID/FREERTOS/PORTABLE/GCC
    sMID/FreeRTOS/portable/GCC/: port.c
  group SMID/CM_BACKTRACE
    sMID/cm_backtrace/: cm_backtrace.c
  group SMID/CM_BACKTRACE/FAULT_HANDLER/KEIL
    sMID/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group SMID/CM_BACKTRACE/FAULT_HANDLER/IAR
    sMID/cm_backtrace/fault_handler/iar/: cmb_fault.S
  group SMID/CM_BACKTRACE/FAULT_HANDLER/GCC
    sMID/cm_backtrace/fault_handler/gcc/: cmb_fault.S
  group SMID/ARDUINOFRAMEWORK
    sMID/ArduinoFramework/: abi.cpp itoa.c WString.cpp
  group SMID/ARDUINOFRAMEWORK/AVR
    sMID/ArduinoFramework/avr/: dtostrf.c
  group SUSER
    sUSER/: main.cpp sGCARC_hal_msp.c startup_stm32f405xx.s stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c system_stm32f4xx.c
  group SLIB/STM32F4XX_HAL_DRIVER/SRC
    sLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group SLIB/STM32F4XX_HAL_DRIVER/SRC/LEGACY
    sLIB/STM32F4xx_HAL_Driver/Src/Legacy/: stm32f4xx_hal_can.c stm32f4xx_hal_eth.c
  group <virtual_root>
    sLIB/DSP/: arm_cortexM4lf_math.lib
